* C:\Users\abias\.cursor-tutor\vccdoe\forml\ltspice\izhikevich_neurontemplatetest38.asc
* Generated by LTspice 24.1.9 for Windows.
.include 65nm_bulk_nmos.model
.include 65nm_bulk_pmos.model
Vc N015 0 0.14
I1 N016 N011 2p
Vdd1 N003 0 0.18
Vdd2 N001 0 0.18
Vd N005 0 0.14
Cu N009 N016 300f
Cv N011 0 20f
C1 N008 0 250f
M1 N006 N006 N003 N003 PMOS2 w=300n l=125n
M3 N011 N006 N003 N003 PMOS2 w=300n l=125n
M4 N009 N006 N003 N003 PMOS2 w=650n l=90n
M8 N009 N004 N005 N005 PMOS2 w=1.3u l=125n
M10 N013 N011 N001 N001 PMOS2 w=1u l=100n
M13 N012 N002 N001 N001 PMOS2 w=200n l=100n
M17 N004 N002 N001 N001 PMOS2 w=100n l=100n
M18 N008 N010 N001 N001 PMOS2 w=200n l=100n
M2 N006 N011 N016 N016 NMOS2 w=300n l=125n
M5 N011 N009 N016 N016 NMOS2 w=400n l=600n
M6 N009 N009 N016 N016 NMOS2 w=700n l=150n
M7 N011 N002 N015 N015 NMOS2 w=175n l=350n
M9 N013 N011 0 0 NMOS2 w=100n l=100n
M11 N010 N013 0 0 NMOS2 w=1u l=100n
M14 N014 N010 0 0 NMOS2 w=100n l=100n
M15 N008 N010 0 0 NMOS2 w=100n l=250n
M16 N004 N002 N014 N014 NMOS2 w=100n l=100n
M12 N010 N013 N012 N012 PMOS2 w=100n l=100n
M19 N002 N008 N007 N007 PMOS2 l=50n w=25n
M20 N002 N008 0 0 NMOS2 l=0.5u w=2.5u
Vdd3 N007 0 0.18
V1 N008 0 PULSE(0.18 0 10u 0 0 15u 300u 10)
* U
* V
.probe V(N011) V(N009)

.tran 100n 6ms
.control

run
plot v(N011) v(N009)

.endc
.end
